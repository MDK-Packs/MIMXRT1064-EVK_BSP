# Keil uVision project Platform.uvprojx, settings and files
target MIMXRT1064-EVK (6140001::V6.14.1::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Platform
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xbfc00
  memory RVCT7: RAM 0x202bfc00 size 0x400
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: Platform.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group MCUXpresso
    ./: MIMXRT1064-EVK.mex
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:Ethernet MAC 1.1.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.1.0, CMSIS Driver:VIO:Board 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis_edma 2.0.1, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:SDK Drivers:clock 2.3.2, Device:SDK Drivers:common 2.2.4, Device:SDK Drivers:dmamux 2.0.4, Device:SDK Drivers:edma 2.3.2, Device:SDK Drivers:enet 2.3.0, Device:SDK Drivers:gpio 2.0.3, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.3.0, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.3.0, Device:SDK Drivers:sdhc 2.5.1, Device:SDK Drivers:xip_board 2.0.0, Device:SDK Drivers:xip_device 2.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1064_startup 1.1.0
